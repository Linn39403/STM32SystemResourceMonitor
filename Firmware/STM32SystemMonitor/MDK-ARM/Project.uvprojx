# Keil uVision project Project.uvprojx, settings and files
target STM32746G-DISCOVERY_USBD-FS (ARM-ADS)
  device: STM32F746NGHx STMicroelectronics
  cpu: IROM(0x08000000-0x080FFFFF) IRAM(0x20000000-0x2004FFFF) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM32746G-DISCOVERY_USBD-FS
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx,USE_STM32746G_DISCO,USE_USB_FS
  c misc: --C99
  c include: ../Inc;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Inc;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32746G-Discovery;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Middlewares/STM32_USBD_Library/Class/HID
    ../Drivers/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Application/User
    ../Src/: stm32f7xx_it.c usbd_desc.c usbd_conf.c main.c usbd_cdc_if.c ringbuffer.c
    ./: stm32f7xx_hal_msp.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_usart.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_pwr.c stm32f7xx_hal.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_dma.c stm32f7xx_ll_usb.c stm32f7xx_hal_pcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_cortex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_ll_fmc.c stm32f7xx_hal_sdram.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_dma2d.c
  group Middlewares/STM32_USBD_Library/Core
    ../Drivers/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_ioreq.c usbd_core.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers/BSP/STM32746G_DISCOVERY
    ../Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_sdram.c stm32746g_discovery_lcd.c
    ../Drivers/BSP/Components/ft5336/: ft5336.c
    ../Drivers/BSP/Components/wm8994/: wm8994.c
  group Doc
    ../: readme.txt
  group Middlewares/STemWin/Lib
    ../Middlewares/STemWin/Lib/: STemWin528_CM7_Keil.lib
  group Middlewares/STemWin/Config
    ../Drivers/STemWin/: GUI_X_OS.c GUIConf.c LCDConf.c GUI_X.c
    ./: Image.c
    ../Src/: System MonitorDLG.c
target STM32746G-DISCOVERY_USBD-HS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.14.1
  cpu: as above
  output: STM32746G-DISCOVERY_USBD-HS
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx,USE_STM32746G_DISCO,USE_USB_HS
  c misc: --C99
  c include: ..\Inc;..\Drivers\STM32_USB_Device_Library\Core\Inc;..\Drivers\STM32_USB_Device_Library\Class\CDC\Inc;..\Drivers\STM32F7xx_HAL_Driver\Inc;..\Drivers\BSP\STM32746G-Discovery;..\Drivers\CMSIS\Device\ST\STM32F7xx\Include;..\Drivers\CMSIS\Include;..\Drivers\STemWin\inc;..\Drivers\STemWin;..\Drivers\Fonts
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 5.5.0
